# Altium project Impedance.PrjPcb
1 sheet, 0 parts. Net scope: global (net labels, ports and power ports of the same name join across sheets).
Board file: IMPEDANCE1.PcbDoc

## Sheet IMPEDANCE1.SchDoc
size A3; SheetNumber: 1; SheetTotal: 1